RDEPENDS:packagegroup-meta-networking-connectivity:remove = "miniupnpd"
RDEPENDS:packagegroup-meta-networking-support:remove = "arptables yp-tools ypbind-mt"

