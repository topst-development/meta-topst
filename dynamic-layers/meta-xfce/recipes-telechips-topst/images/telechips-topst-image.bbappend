IMAGE_INSTALL += " \
    packagegroup-xfce-extended \
	packagegroup-xfce-multimedia \
	packagegroup-meta-networking \
	network-manager-applet \
"
