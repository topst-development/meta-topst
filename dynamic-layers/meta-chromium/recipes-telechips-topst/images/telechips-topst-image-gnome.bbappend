IMAGE_INSTALL += " \
	chromium-ozone-wayland \
"
