IMAGE_INSTALL += "firefox"
