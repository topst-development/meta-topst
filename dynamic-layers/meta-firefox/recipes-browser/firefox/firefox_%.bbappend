PACKAGECONFIG:append = "gpu webgl"
