DESCRIPTION = "This image provides topst image for multimedia"

require telechips-topst-image-minimal.bb

IMAGE_INSTALL += " \
    packagegroup-telechips-topst-multimedia \
"
