PACKAGECONFIG:append = " hls openssl opusparse"
PACKAGECONFIG:append = " openh264 openjpeg openmpt v4l2codecs webp libde265"
